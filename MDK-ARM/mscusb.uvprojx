# Keil uVision project mscusb.uvprojx, settings and files
target mscusb (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: mscusb
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;  ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_hcd.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c usbh_conf.c fatfs.c usb_host.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c usbh_core.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
software components: CMSIS:CORE 4.1.0
